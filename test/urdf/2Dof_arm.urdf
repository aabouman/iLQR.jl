Commit message: Tweaked URDF base mass

File: test/urdf/2Dof_arm.urdf (robot description, URDF)
Before this commit: robot robot_name, 3 links, 2 joints
Links:
- link base_link: mass 300 -> 30
